# Keil uVision project gps-radio-tiva-c.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gps-radio-tiva-c
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 DEBUG
  c include: C:\Tools\ti\TivaWare_C_Series-2.1.0.12573
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./src/: aprs_board.h aprs_board.c common.h nmea_messages.h nmea_messages.c main.c signals.h signals.c timer.h timer.c tiva_c.h tiva_c.c uart.h uart_impl.h uart_initialize.c uart_read.c uart_write.c
  group Libraries
    ./lib/: driverlib.lib
  group Libraries-c
    ./lib-c/: startup_rvmdk.S
